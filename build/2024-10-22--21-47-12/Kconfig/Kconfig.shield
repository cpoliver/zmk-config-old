## build/2024-10-22--21-47-12/Kconfig/Kconfig.shield
```kconfig
osource "/Users/cpoliver/code/keyboards/zmk/app/boards/shields/*/Kconfig.shield"
```
